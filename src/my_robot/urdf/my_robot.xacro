Commit message: FinalVersion

File: src/my_robot/urdf/my_robot.xacro (robot description, xacro)
@@ -168,5 +168,5 @@
   <parent link="chassis"/>
   <child link="hokuyo"/>
-  <axis xyz="0 1 0" rpy="0 0 0"/>
+  <!--<axis xyz="0 1 0" rpy="0 0 0"/>-->
  </joint>
  <link name="hokuyo">
